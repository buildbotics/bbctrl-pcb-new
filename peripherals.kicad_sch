File: peripherals.kicad_sch (KiCad schematic)
At the start: 32 parts, among them J5 DB25_Male_MountingHoles, J6 Conn_02x08_Odd_Even, U16 ISL83485IBZ, U27 ZXTR2012Z-7, U29 LM358

Commit message: removed autosave file and corrected schematic electrical rules check warnings and errors
Parts:
- removed U29: LM358, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm, symbol Amplifier_Operational:LM358
- added U29: LM358, symbol 1LibBBCTRL:LM358
Connections:
- net GND: now also U29.4 (V-)
- net at R82.2, R83.1: now also U29.1
- net at R81.2, R82.1: now also U29.2 (-)
- net at C95.1, R80.2: now also U29.3 (+)
- net at C94.1, C96.1, U27.3 (VOUT): now also U29.8 (V+)
Changed lines of the file:
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@@
   (junction (at 155.702 66.802) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 193.04 92.71) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 173.482 85.344) (diameter 0) (color 0 0 0 0)
   )
@@
   )
   (junction (at 109.982 94.996) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 193.04 92.71) (diameter 0) (color 0 0 0 0)
   )
   (junction (at 142.24 33.274) (diameter 0) (color 0 0 0 0)
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 193.04 110.998) (xy 193.04 109.728))
-    (stroke (width 0) (type default) (color 0 0 0 0))
-  )
   (wire (pts (xy 75.438 36.83) (xy 82.55 36.83))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 193.04 92.71) (xy 193.04 94.488))
-    (stroke (width 0) (type default) (color 0 0 0 0))
-  )
   (wire (pts (xy 74.168 34.29) (xy 85.852 34.29))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
   )
   (wire (pts (xy 158.496 99.568) (xy 158.496 104.902))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
+  (wire (pts (xy 193.04 92.71) (xy 193.04 94.234))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (effects (font (size 1.27 1.27)) (justify right))
   )
-  (symbol (lib_id "Amplifier_Operational:LM358") (at 195.58 102.108 0) (unit 1)
-    (in_bom yes) (on_board yes)
-    (property "Reference" "U29" (id 0) (at 197.104 98.552 0))
-    (property "Value" "LM358" (id 1) (at 195.072 102.108 0))
-    (property "Footprint" "Package_SO:SOIC-8_3.9x4.9mm_P1.27mm" (id 2) (at 195.58 102.108 0)
+  (symbol (lib_id "1LibBBCTRL:LM358") (at 195.58 102.108 0) (unit 1)
+    (in_bom yes) (on_board yes)
+    (property "Reference" "U29" (id 0) (at 197.358 98.552 0))
+    (property "Value" "LM358" (id 1) (at 194.564 102.108 0))
+    (property "Footprint" "" (id 2) (at 195.58 102.108 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (pin "2")
   )
+  (symbol (lib_id "1LibBBCTRL:LM358") (at 195.58 101.854 0) (unit 3)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "U29" (id 0) (at 193.675 101.0193 0)
+      (effects (font (size 1.27 1.27)) (justify left) hide)
+    )
+    (property "Value" "LM358" (id 1) (at 193.675 103.5562 0)
+      (effects (font (size 1.27 1.27)) (justify left) hide)
+    )
+    (property "Footprint" "" (id 2) (at 195.58 101.854 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "http://www.ti.com/lit/ds/symlink/lm2904-n.pdf" (id 3) (at 195.58 101.854 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (pin "3")
+    (pin "5")
+    (pin "6")
+    (pin "7")
+    (pin "4")
+    (pin "8")
+  )
   (symbol (lib_id "power:GND") (at 237.49 116.332 270) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
@@
     (pin "1")
   )
-  (symbol (lib_id "Amplifier_Operational:LM358") (at 195.58 102.108 0) (unit 3)
-    (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "U29" (id 0) (at 193.675 101.2733 0)
-      (effects (font (size 1.27 1.27)) (justify left) hide)
-    )
-    (property "Value" "LM358" (id 1) (at 193.675 103.8102 0)
-      (effects (font (size 1.27 1.27)) (justify left) hide)
-    )
-    (property "Footprint" "Package_SO:SOIC-8_3.9x4.9mm_P1.27mm" (id 2) (at 195.58 102.108 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "http://www.ti.com/lit/ds/symlink/lm2904-n.pdf" (id 3) (at 195.58 102.108 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (pin "2")
-    (pin "3")
-    (pin "5")
-    (pin "6")
-    (pin "7")
-    (pin "4")
-    (pin "8")
-  )
   (symbol (lib_id "power:GND") (at 142.24 24.892 180) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
@@
     (pin "2")
   )
-  (symbol (lib_id "power:GND") (at 193.04 110.998 0) (unit 1)
-    (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#PWR0218" (id 0) (at 193.04 117.348 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "GND" (id 1) (at 193.04 115.4414 0))
-    (property "Footprint" "" (id 2) (at 193.04 110.998 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (id 3) (at 193.04 110.998 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+  (symbol (lib_id "power:GND") (at 193.04 109.474 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "#PWR0218" (id 0) (at 193.04 115.824 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (id 1) (at 193.04 113.9174 0))
+    (property "Footprint" "" (id 2) (at 193.04 109.474 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 193.04 109.474 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: cleared all pcb drc errors and warnings
Parts:
- U29: footprint (none) -> Package_SO:SOIC-8_3.9x4.9mm_P1.27mm
Changed lines of the file:
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@@
     (title "Peripherals")
     (company "Buildbotics LLC")
-    (comment 1 "Copyrught (c) 2016-2022, Buildbotics LLC")
+    (comment 1 "Copyright (c) 2016-2022, Buildbotics LLC")
     (comment 2 "Licensed under CERN-OHL-S v2 ")
   )
@@
     (property "Reference" "U29" (id 0) (at 197.358 98.552 0))
     (property "Value" "LM358" (id 1) (at 194.564 102.108 0))
-    (property "Footprint" "" (id 2) (at 195.58 102.108 0)
+    (property "Footprint" "Package_SO:SOIC-8_3.9x4.9mm_P1.27mm" (id 2) (at 195.58 102.108 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
-    (property "Footprint" "" (id 2) (at 195.58 101.854 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Footprint" "Package_SO:SOIC-8_3.9x4.9mm_P1.27mm" (id 2) (at 195.58 101.854 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: replaced some parts numbers with parts that are available
Parts:
- C81, C82, C83: Model CL21C131JBANNNC -> 08055A131JAT2A
- U29: Model (none) -> LM358
Changed lines of the file:
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@@
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Model" "LM358" (id 4) (at 195.58 102.108 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Model" "LM358" (id 4) (at 195.58 102.108 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Model" "CL21C131JBANNNC" (id 4) (at 75.438 48.26 0)
+    (property "Model" "08055A131JAT2A" (id 4) (at 75.438 48.26 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Model" "CL21C131JBANNNC" (id 4) (at 88.138 48.514 0)
+    (property "Model" "08055A131JAT2A" (id 4) (at 88.138 48.514 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Model" "CL21C131JBANNNC" (id 4) (at 85.852 30.48 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Model" "08055A131JAT2A" (id 4) (at 85.852 30.48 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: corrections after first KiCad build
Parts:
- removed C93: 1uF, Capacitor_THT:C_Radial_D5.0mm_H5.0mm_P2.00mm, symbol Device:C_Polarized_Small_US
- removed C94: 10uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, symbol Device:C
- removed U27: ZXTR2012Z-7, Project_Footprints_Library:ZXTR2012Z7, symbol 1LibBBCTRL:ZXTR2012Z-7
- added C80: 1u, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, symbol Device:C
- added Q25: BC856B, Project_Footprints_Library:BC856B_215, symbol 1LibBBCTRL:BC856B
- added R88: 56k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, symbol Device:R_US
- added R89: 62, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, symbol Device:R_US
- added TP23: 12V, Connector_PinHeader_2.54mm:PinHeader_1x01_P2.54mm_Vertical, symbol Connector:TestPoint
- added U25: BSP16T1G, Project_Footprints_Library:BSP16T1G, symbol 1LibBBCTRL:BSP16T1G
- added Z3: 12V, Package_TO_SOT_SMD:SOT-23, symbol 1LibBBCTRL:MMBZ5242BLT3G
- U29: footprint Package_SO:SOIC-8_3.9x4.9mm_P1.27mm -> (none); Model LM358 -> (none)
Connections:
- net GND: now also C80.2, R88.2, Z3.1
- net Vs: now also Q25.2 (E), R89.1
- net at C96.1, U29.8 (V+): now also C80.1, TP23.1, U25.3 (E), Z3.3
- new net: Q25.1 (B), R89.2, U25.2 (C), U25.4 (C)
- new net: Q25.3 (C), R88.1, U25.1 (B)
Other:
- moved on the sheet: J6

Commit message: put all schematics on 50 mil grid
Other:
- moved on the sheet: C80, C83, C86, C95, J6, Q25, R70, R71, R72, R79, R80, R81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

Commit message: minor corrections in prep for new build
Parts:
- removed J5: DB25_Male_MountingHoles, Project_Footprints_Library:182025113R161, symbol Connector:DB25_Male_MountingHoles
- added J5: DB25_Male, Project_Footprints_Library:182025113R161, symbol 1LibBBCTRL:DB25_Male
- U29: Model (none) -> LM358
Connections:
- net +5V: now also J5.20 (P20)
- net GND: now also J5.0 (PAD), J5.19 (P19), J5.25 (P25), J5.7
- net analog_1: now also J5.24 (P24)
- net analog_2: now also J5.18 (P18)
- net in_10: now also J5.10
- net in_11: now also J5.11
- net in_12: now also J5.12
- net in_22: now also J5.22 (P22)
- net in_23: now also J5.23 (P23)
- net in_3: now also J5.3
- net in_4: now also J5.4
- net in_5: now also J5.5
- net in_8: now also J5.8
- net in_9: now also J5.9
- net out_1: now also J5.1
- net out_15: now also J5.15 (P15)
- net out_16: now also J5.16 (P16)
- net out_2: now also J5.2
- net out_21: now also J5.21 (P21)
- net rs485+: now also J5.14 (P14)
- net rs485-: now also J5.13
- net spin_0to10: now also J5.6
- net spin_pwm: now also J5.17 (P17); no longer R79.2, R80.1
- new net spin_pwm_3: R79.2, R80.1
Other:
- added sheet 3_to_5_17 (level_shifter.kicad_sch)
- moved on the sheet: C48, C71, C80, C95, C96, Q25, R79, R80, R81, R82, R83, R88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

Commit message: added footprint to U29
Parts:
- C80: Model CL21B105KBFNNNE -> CC0805KKX7R7BB105
- U29: footprint (none) -> Package_SO:SOIC-8_3.9x4.9mm_P1.27mm
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
-    (property "Footprint" "" (id 2) (at 181.61 101.854 0)
+    (property "Footprint" "Package_SO:SOIC-8_3.9x4.9mm_P1.27mm" (id 2) (at 181.61 101.854 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (property "Reference" "U29" (id 0) (at 173.7614 101.7524 0))
     (property "Value" "LM358" (id 1) (at 180.34 102.997 0))
-    (property "Footprint" "" (id 2) (at 181.61 102.235 0)
+    (property "Footprint" "Package_SO:SOIC-8_3.9x4.9mm_P1.27mm" (id 2) (at 181.61 102.235 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://media.digikey.com/pdf/Data%20Sheets/Samsung%20PDFs/CL21B105KBFNNNE_Spec.pdf" (id 3) (at 130.175 105.41 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Model" "CL21B105KBFNNNE" (id 4) (at 130.175 105.41 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Datasheet" "" (id 3) (at 130.175 105.41 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Model" "CC0805KKX7R7BB105" (id 4) (at 130.175 105.41 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
